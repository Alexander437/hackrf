options:
  parameters:
    generate_options: qt_gui
    id: example_1
    output_language: python
    title: Hackrf one first example
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '256'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
